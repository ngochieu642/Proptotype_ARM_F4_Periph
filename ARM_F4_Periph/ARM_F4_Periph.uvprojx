# Keil uVision project ARM_F4_Periph.uvprojx, settings and files
target ARM_F4_Periph (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM_F4_Periph +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, HSE_VALUE=8000000
  c include: .\User;.\STM32F4xx_StdPeriph_Driver\inc;.\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;.\CMSIS\Device\ST\STM32F4xx\Include;.\CMSIS\Include;.\STM32F4xx_StdPeriph_Driver\src;..\Prototype_Periph_Project_F4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group User
    ./User/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h main.h
  group StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_flash.c stm32f4xx_rcc.c
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c
